# Keil uVision project SampleNUC100.uvproj, settings and files
target F17 (ARM-ADS)
  device: NUC120RD2BN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: F16_V1_17_010 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: AD_16_C608_1000PICS
  c include: ..\..\..\..\..\uCOS-II\Source;..\OS-Probe;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M0\RealView;..\..\..\..\..\uC-CPU\ARM-Cortex-M0\RealView;..\..\..\..\..\uC-CPU;..\BSP;..\..\..\..\NUC1XX_BSP\CMSIS\CM0;..\..\..\..\NUC1XX_BSP\NuvotonPlatform_Keil\Include;..\..\..\..\NUC1XX_BSP\NuvotonPlatform_Keil\Include\Driver;.\aa;.\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group APP
    ./aa/: app.c communication.c keydispose.c keyscan.c led.c performance.c dspperf.c Fuc_ph.c
  group BSP
    ../BSP/: bsp.c
    ../../../../NUC1XX_BSP/NuvotonPlatform_Keil/Src/Driver/: DrvUART.c retarget.c DrvGPIO.c DrvSYS.c DrvUSB.c DrvTIMER.c DrvADC.c DrvI2C.c
    ../../../../NUC1XX_BSP/CMSIS/CM0/startup/arm/: startup_NUC1xx.s
    ./: HIDSysIO.c ucos2.lib
    ./aa/: V6MDebug.c HID_API.c
  group uC-CPU
    ../../../../../uC-CPU/ARM-Cortex-M0/RealView/: cpu_a.asm
    ../../../../NUC1XX_BSP/CMSIS/CM0/: core_cm0.c system_NUC1xx.c
  group uCOS-II/Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M0/RealView/: os_cpu_a.asm
    ../../../../../../../: 说明.txt
